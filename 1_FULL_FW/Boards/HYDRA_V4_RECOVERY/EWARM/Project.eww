<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HYDRA_V4_RECOVERY.ewp</path>
  </project>
  <batchBuild />
</workspace>
